# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf --bin --output .\Out\TIZA_BOOT_V30_150324.bin .\Out\Project.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Lib/cmsis/: core_cm3.c system_stm32f10x.c
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_iwdg.c
  group src
    ../src/: stm32f10x_it.c driver.c selfdef.c flash.c boot.c fram.c
  group inc
    ../inc/: stm32f10x_it.h driver.h include.h selfdef.h flash.h boot.h fram.h
    ../Lib/inc/: stm32f10x_conf.h
    ../Lib/cmsis/: stm32f10x.h
  group main
    ../main/: main.c
